IMAGE_INSTALL:append = " ubuntu-xenguest"
